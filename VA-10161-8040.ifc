Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2020-09-17T08:41:09
Written by: Xbim File Processor version 4.0.0.0
Made in: Xbim version 4.0.0.0

# IfcDistributionPort (2)
Name | FlowDirection
 | SOURCE
 | SINK

# IfcFlowTerminal: Vancouver 40 Bollards
In: Default Building
Type - Description: - Lamp COB - CRI Ra > 80 - MacAdam Ellipse 3 SDCM - Colour 3000K , 4000K - Die-cast aluminium housing and extruded aluminium column pre-treated before powder coating ensuring high corrosion resistance - Single cable entry - One IP68 connector supplied with 0.2 m of 3 x1.0 sqmm outdoor cable - Stainless steel fasteners in grade 316 - Durable silicone rubber gasket - High-efficiency optical reflector - Clear toughened glass for VANCOUVER 3,VANCOUVER 4, VANCOUVER 11, VANCOUVER 12,VANCOUVER 13, VANCOUVER 31 - Silicone lens for VANCOUVER 33, VANCOUVER 34,VANCOUVER 35, VANCOUVER 36, VANCOUVER 37, VANCOUVER 38, VANCOUVER 39,VANCOUVER 40 - Integral control gear; PredefinedType: DIRECTIONSOURCE
Material: layer 10 mm
Marketing Information - Emergency lighting possible: no; Product group: Vancouver, Bollards; Housing color: White, Black, Silver
General Information - Article number: VA-10161-8040; Article name: Vancouver 40 Bollards; Weight: 13 kg; Case length: 24 cm; Case width: 24 cm; Case height: 100 cm; Uld creation date: 17.09.2020 06:41:09
Pset_ElectricalDeviceCommon - ElectricalDeviceNominalPower: 21 W
Pset_LightFixtureTypeCommon - NumberOfSources: 1; TotalWattage: 21 W; LightFixtureMountingType: Standing; LightFixturePlacingType: Floor; ManufacturersSpecificInformation: LIGMAN

# IfcFlowTerminal: Vancouver 40 Bollards
Type - Description: Default Lamp Description; PredefinedType: FLUORESCENT
Photometric Information - Lamp names: Vancouver 40 Bollards; Light output ratio: 1; Luminous flux: 636 lm
Pset_LampTypeCommon - ContributedLuminousFlux: 636 lm; LightEmitterNominalPower: 21 W; Spectrum: 380: 12934, 385: 1155, 390: 11614, 395: 10494, 400: 10484, 405: 10279, 410: 968, 415: 11352, 420: 17493, 425: 49381, 430: 110001, 435: 213323, 440: 422394, 445: 673726, 450: 939462, 455: 97829, 460: 851938, 465: 670014, 470: 549521, 475: 442322, 480: 39367, 485: 37832, 490: 392506, 495: 423255, 500: 468951, 505: 509823, 510: 551923, 515: 57673, 520: 59894, 525: 611155, 530: 623829, 535: 629598, 540: 636475, 545: 645361, 550: 655589, 555: 671682, 560: 690295, 565: 709359, 570: 730587, 575: 748998, 580: 767832, 585: 786295, 590: 801043, 595: 812518, 600: 821303, 605: 827334, 610: 827494, 615: 819016, 616: 814072, 617: 810179, 618: 806287, 619: 802012, 620: 797737, 625: 764787, 630: 724964, 635: 680899, 640: 638133, 645: 594845, 650: 555125, 655: 51894, 660: 486181, 665: 454614, 670: 422297, 675: 388355, 680: 352992, 685: 318193, 690: 282697, 695: 245701, 700: 215906, 705: 189853, 710: 163229, 715: 14476, 720: 12737, 725: 114158, 730: 97674, 735: 85444, 740: 75708, 745: 68751, 750: 61453, 755: 56451, 760: 52251; ColorRenderingIndex: 80
